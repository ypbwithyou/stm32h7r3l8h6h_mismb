# Keil uVision project atk_h7r3.uvprojx, settings and files
target atk_h7r3 (6220000::V6.22::ARMCLANG)
  device: STM32H7R3L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.1.0
  cpu: IRAM(0x00000000,0x00010000) IRAM2(0x20000000,0x00010000) IROM(0x08000000,0x00010000) XRAM(0x24000000,0x00072000) XRAM2(0x30000000,0x00008000) XRAM3(0x38800000,0x00001000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h7r3 +hex
  AfterMake: fromelf --bin -o ../../Output/atk_h7r3.bin ../../Output/atk_h7r3.axf
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R3xx,USE_USB_HS
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc;..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc\Legacy;..\..\Middlewares;..\..\User;..\..\Middlewares\USB\USB_APP;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\CompositeBuilder\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Core\Inc;..\..\Drivers\LIBS\lib_usb_protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0xb000
  memory RVCT6: RAM 0x24000000 size 0x72000
  memory RVCT7: RAM 0x30000000 size 0x8000
  memory RVCT8: RAM 0x38800000 size 0x1000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\User\Script\ATK-DNH7R3_flash_ROMxspi1.sct
  link misc: --diag_suppress L6314,L6329
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r3xx.s
  group User
    ../../User/: main.c stm32h7rsxx_it.c collector_processor.c ida_config.c offline_processor.c rs485_processor.c usb_processor.c dataType.c bridge_config.c
    ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
    ../../Drivers/LIBS/lib_file_utils/: file_utils_disk.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_sram.c stm32h7rsxx_ll_fmc.c stm32h7rsxx_hal_spi.c stm32h7rsxx_hal_spi_ex.c stm32h7rsxx_ll_spi.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_sd_ex.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_ll_tim.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_mmc.c stm32h7rsxx_hal_mmc_ex.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_ll_i2c.c stm32h7rsxx_ll_usb.c stm32h7rsxx_hal_rtc.c stm32h7rsxx_hal_rtc_ex.c stm32h7rsxx_ll_rtc.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/HYPERRAM/: hyperram.c
    ../../Drivers/BSP/NORFLASH/: norflash.c norflash_ex.c norflash_mx25um25645g.c norflash_w25q128_dual.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/PCA9554A/: pca9554a.c
    ../../Drivers/BSP/RS485/: rs485.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/TIMER/: gtim.c
    ../../Drivers/BSP/ADS8319/: ads8319.c
    ../../Drivers/BSP/MMC/: mmc_sdcard.c
    ../../Drivers/BSP/SDNAND/: spi_sdnand.c
    ../../Drivers/BSP/RTC/: rtc.c
  group Drivers/LIBS
    ../../Drivers/LIBS/lib_base_calculation/: base_calculation.c calculate_check.c
    ../../Drivers/LIBS/lib_circular_buffer/: CircularBuffer.c
    ../../Drivers/LIBS/lib_dwt/: lib_dwt_timestamp.c
    ../../Drivers/LIBS/lib_usb_protocol/: slidingWindowReceiver_c.c usb_protocol.c
    ../../Drivers/LIBS/lib_file_utils/: file_utils.c
    ../../Drivers/LIBS/lib_ini_fatfs/: ini_fatfs.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c emmc_arbitrator.c
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c
  group Middlewares/USB_CORE
    ../../Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_CLASS
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_scsi.c usbd_msc_data.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/CompositeBuilder/Src/: usbd_composite_builder.c
  group Middlewares/USB_APP
    ../../Middlewares/USB/USB_APP/: usbd_cdc_if.c usbd_conf.c usbd_desc.c usbd_msc_storage_if.c
